<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\core1-bare.ewp</path>
    </project>
    <batchBuild />
</workspace>
