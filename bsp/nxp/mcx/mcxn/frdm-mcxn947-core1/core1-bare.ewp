# IAR project core1-bare.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core1 NXP MCXN947_core1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MCXN947VDF_cm33_core1
  ICCARM.CCIncludePath2: ..\Libraries\CMSIS\Core\Include; ..\Libraries\MCXN947\MCXN947\drivers; ..\Libraries\MCXN947\MCXN947; ..\Libraries\MCXN947\MCXN947\utilities\debug_console_lite; board; ..\Libraries\MCXN947\middleware\multicore\mcmgr; ..\Libraries\MCXN947\components\uart; ..\Libraries\MCXN947\MCXN947\utilities\str
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: core1-bare.bin
  ILINK.IlinkOutputFile: core1-bare.out
  ILINK.IlinkConfigDefines: __use_shmem__=1
  ILINK.IlinkIcfFile: board\linkfile\MCXN947_cm33_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    app/: main.c
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group component/common
    ../Libraries/MCXN947/components/common/: mini_printf.c ringbuffer.c ringbuffer.h utilities.c utilities.h
  group component/uart
    ../Libraries/MCXN947/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../Libraries/MCXN947/MCXN947/: fsl_device_registers.h MCXN947_cm33_core1_features.h system_MCXN947_cm33_core1.c system_MCXN947_cm33_core1.h
  group drivers
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_lpflexcomm.c fsl_lpuart.c fsl_reset.c
  group linkfile
    board/linkfile/: MCXN947_cm33_core1_ram.icf
  group mcmgr
    ../Libraries/MCXN947/middleware/multicore/mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_mcxnx4x.c
  group startup
    ../Libraries/MCXN947/MCXN947/iar/: startup_MCXN947_cm33_core1.s
  group utillities
    ../Libraries/MCXN947/MCXN947/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h
    ../Libraries/MCXN947/MCXN947/utilities/str/: fsl_str.c fsl_str.h
