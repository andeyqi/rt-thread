# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXC444 NXP MCXC444
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXC444VLH; SLCD_PANEL_LCD_S401M16KR_H; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; board; ..\..\..\..\..\libcpu\arm\cortex-m0; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\libc\posix\ipc; ..\..\..\..\..\components\libc\cplusplus; ..\Libraries\drivers; packages\i2c-tools-latest\src; board\slcd_engine; ..\Libraries\CMSIS\Core\Include; ..\Libraries\MCXC444\MCXC444; packages\i2c-tools-latest; board\slcd_engine\LCD-S401M16KR; ..\..\..\..\..\libcpu\arm\common; applications; ..\..\..\..\..\components\drivers\smp; ..\..\..\..\..\components\drivers\spi; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\components\drivers\include; board\MCUX_Config\board; ..\..\..\..\..\components\libc\compilers\common\extension; ..\Libraries\drivers\config; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\finsh; ..\..\..\..\..\include; ..\Libraries\MCXC444\MCXC444\drivers; .; ..\..\..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\MCXC444_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXC444VLH; SLCD_PANEL_LCD_S401M16KR_H; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  group Applications
    applications/: main.c slcd.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPP
    ../../../../../components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group DeviceDrivers
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/misc/: rt_drv_pwm.c
  group Drivers
    board/: board.c
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_i2c.c drv_pin.c drv_rtc.c drv_uart.c
    board/slcd_engine/LCD-S401M16KR/: LCD-S401M16KR.c
    board/slcd_engine/: slcd_engine.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group i2c-tools
    packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
    ../../../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    ../Libraries/MCXC444/MCXC444/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_common_arm.c fsl_cop.c fsl_dac.c fsl_dma.c fsl_ftfx_controller.c fsl_ftfx_flexnvm.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_lpuart.c fsl_lpuart_dma.c fsl_pit.c fsl_pmc.c fsl_rtc.c fsl_sai.c fsl_sai_dma.c fsl_sim.c fsl_slcd.c fsl_smc.c fsl_spi.c fsl_tpm.c fsl_uart.c fsl_uart_dma.c
    ../Libraries/MCXC444/MCXC444/iar/: startup_MCXC444.s
    ../Libraries/MCXC444/MCXC444/: system_MCXC444.c
